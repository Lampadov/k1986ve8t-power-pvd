# Keil uVision project PVD_Adaptive.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MDR32F8 Milandr
  pack: Keil.MDR1986VE8T.0.5
  cpu: IRAM(0x20000000,0x6000) IROM(0x20006000,0x2000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: PVD_Adaptive
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x20006000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group user
    ./: main.c
software components: CMSIS:CORE 5.5.0, Board Support:Board Setup 0.5, Device:Startup 0.5, Drivers:CLKCTRL 0.5, Drivers:PORT 0.5
